# IAR project Panel_V10.ewp, settings and files
configuration Panel_V10 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZG ST STM32F429ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_BPP=16
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Src; ../Middlewares/ST/touchgfx/framework/include; ../Src/generated/fonts/include; ../Src/generated/images/include; ../Src/generated/texts/include; ../Src/generated/gui_generated/include; ../Src/gui/include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; E:\M.Mozaffari\21_Ongoing_Tasks\STM32F429_Panel\Panel_V.11_LTDC_NEW_4.3_(V10.0+FREERTOS)\Src\XPT; C:\Users\m.mozafari\Desktop\Panel_V.13_LTDC_NEW_4.3_(V11+NewScreen)\Src\generated\gui_generated\include\gui_generated; C:\Users\Ahmad\WorkSpace\PosheshHayeNanoSakhtar\LCD_BOARD_Firmware\Panel\Panel_V.14_LTDC_NEW_4.3_(V13-Modified)\Src\XPT; C:\Users\Ahmad\Desktop\Panel\Panel_V.14_LTDC_NEW_4.3_(V13-Modified)\Inc; C:\Users\Ahmad\WorkSpace\PosheshHayeNanoSakhtar\LCD_BOARD_Firmware\Panel\Panel_V.14_LTDC_NEW_4.3_(V13-Modified)\Drivers\CMSIS; C:\Users\Ahmad\WorkSpace\PosheshHayeNanoSakhtar\LCD_BOARD_Firmware\Panel\Panel_V.14_LTDC_NEW_4.3_(V13-Modified)\Drivers\STM32F4xx_HAL_Driver\Inc; C:\Users\Ahmad\WorkSpace\PosheshHayeNanoSakhtar\LCD_BOARD_Firmware\Panel\Panel_V.14_LTDC_NEW_4.3_(V13-Modified)\Src; C:\Users\Ahmad\WorkSpace\PosheshHayeNanoSakhtar\LCD_BOARD_Firmware\Panel\Panel_V.14_LTDC_NEW_4.3_(V13-Modified)\Inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Panel_V10.hex
  ILINK.IlinkOutputFile: Panel_V10.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkAdditionalLibs: ../Middlewares/ST/touchgfx/lib/core/cortex_m4f/IAR8.x/touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: app_touchgfx.c freertos.c main.c OSWrappers.cpp STM32DMA.cpp stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c STM32TouchController.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp TouchGFXGPIO.cpp TouchGFXHAL.cpp
  group Application/User/XPT
    ../Src/XPT/: delay.c delay.h xpt2046.c xpt2046.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c
  group generated/fonts
    ../Src/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_times_8_4bpp_0.cpp Font_timesbd_28_4bpp_0.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_11_4bpp_0.cpp Font_verdana_17_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp Font_verdana_7_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_times_8_4bpp.cpp Kerning_timesbd_28_4bpp.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_11_4bpp.cpp Kerning_verdana_17_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Kerning_verdana_7_4bpp.cpp Table_times_8_4bpp.cpp Table_timesbd_28_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_11_4bpp.cpp Table_verdana_17_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp Table_verdana_7_4bpp.cpp UnmappedDataFont.cpp
  group generated/gui_generated/common
    ../Src/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group generated/gui_generated/containers
    ../Src/generated/gui_generated/src/containers/: CustomContainer1Base.cpp CustomContainer2Base.cpp
  group generated/gui_generated/logoscreen_screen
    ../Src/generated/gui_generated/src/logoscreen_screen/: LogoScreenViewBase.cpp
  group generated/gui_generated/mainscreen_screen
    ../Src/generated/gui_generated/src/mainscreen_screen/: MainScreenViewBase.cpp
  group generated/gui_generated/screen1_screen
    ../Src/generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
  group generated/images
    ../Src/generated/images/src/: BitmapDatabase.cpp image_touchgfx_logo.cpp
  group generated/images/__designer
    ../Src/generated/images/src/__designer/: image_Blue_Buttons_Round_Edge_small.cpp image_Blue_Buttons_Round_Edge_small_pressed.cpp image_Blue_Icons_Down_arrow_32.cpp image_Blue_Textures_church.cpp
  group generated/texts
    ../Src/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group gui/common
    ../Src/gui/src/common/: FrontendApplication.cpp
  group gui/containers
    ../Src/gui/src/containers/: CustomContainer1.cpp CustomContainer2.cpp
  group gui/logoscreen_screen
    ../Src/gui/src/logoscreen_screen/: LogoScreenPresenter.cpp LogoScreenView.cpp
  group gui/mainscreen_screen
    ../Src/gui/src/mainscreen_screen/: MainScreenPresenter.cpp MainScreenView.cpp
  group gui/model
    ../Src/gui/src/model/: Model.cpp
  group gui/screen1_screen
    ../Src/gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
